SRC_URI += "file://Linux_for_Tegra"

#addtask do_configure before do_preconfigure

#do_configure () {
#	cp -r ${WORKDIR}/jetson-orin-nx-devkit/Linux_for_Tegra ${S}
#}


